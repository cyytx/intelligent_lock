# Keil uVision project smart_lock.uvprojx, settings and files
target smart_lock (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: smart_lock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ./Core/Inc;./FATFS/Target;./FATFS/App;./LIBJPEG/App;./LIBJPEG/Target;./Drivers/STM32F7xx_HAL_Driver/Inc;./Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;./Middlewares/Third_Party/FreeRTOS/Source/include;./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;./Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;./Middlewares/Third_Party/FatFs/src;./Middlewares/Third_Party/LibJPEG/include;./Drivers/CMSIS/Device/ST/STM32F7xx/Include;./Drivers/CMSIS/Include;.\user;.\user\ov2640;.\user\lcd;.\FATFS\App;.\FATFS\Target;.\Middlewares\Third_Party\FatFs\src
  asm include: .\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./Core/Startup/: startup_stm32f767xx.s
  group Application/User/Core
    ./Core/Src/: freertos.c main.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ./Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_spi.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c
  group Drivers/CMSIS
    ./Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group user
    ./user/: led.c uart.c sg90.c nfc.c ble.c beep.c key.c delay.c fingerprint.c face.c sdcard.c
    ./user/ov2640/: ov2640.c ov2640_i2c.c camera.c
    ./user/lcd/: lcd.c lcd_init.c
  group fatfs
    ./FATFS/Target/: sd_diskio.c bsp_driver_sd.c
    ./Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ./FATFS/App/: fatfs.c
software components: CMSIS:CORE 5.3.0
